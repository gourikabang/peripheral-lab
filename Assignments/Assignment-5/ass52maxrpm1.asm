CPU "8085.TBL"
HOF "INT8"

HXDSP: EQU 034FH
OUTPUT: EQU 0389H
GTHEX: EQU 030EH
RDKBD: EQU 03BAH
CMD55: EQU 03H
PORTA: EQU 00H
MEM: EQU 8000H
ORG 9C00H
MVI A,80H
OUT 03H

MVI A,88H
LOOP:
OUT 00H
CALL DELAY
RRC
JMP LOOP

DELAY:
	PUSH PSW
	LXI H,0001H

DELAY20:
	LXI D,00FFH
DELAY10:
	DCX D
	MOV A,D
	ORA E
	JNZ DELAY10
	DCX H
	MOV A,H
	ORA L
	JNZ DELAY20
	POP PSW
	RET

