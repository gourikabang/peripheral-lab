CPU "8085.TBL"
HOF "INT8"

HXDSP: EQU 034FH
OUTPUT: EQU 0389H

ORG 9C00H
MVI A,80H
OUT 43H

MVI A,000H
STA 8001H

WAVE:
LDA 8001H
OUT 40H
OUT 41H

CALL DELAY
LDA 8001H
ADI 010H
STA 8001H
CPI 0F0H
JNZ WAVE

LOOP:
LDA 8001H
OUT 40H
OUT 41H

CALL DELAY
LDA 8001H
SUI 010H
STA 8001H
LDA 8001H
CPI 00H
JNZ LOOP
JMP WAVE

DELAY:
LXI D,7FFFH
DELAY_LOOP:
DCX D
MOV A,D
ORA E
JNZ DELAY_LOOP
RET
